Commit message: Updated bullet library

File: ProjectRedShadow/ProjectRedShadow/libs/bullet/data/quadruped/quadruped.urdf (robot description, URDF)
Before this commit: robot quadruped, 25 links, 24 joints
Links:
- link base_chassis_link: mass 1. -> 3.2
